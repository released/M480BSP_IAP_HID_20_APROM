LOAD_ROM_1  0x10000 0x70000
{
	APROM_Bootloader.bin  0x10000 0x70000
	{
		startup_M480.o (RESET, +FIRST)
        .ANY (+RO)
	}
	
	SRAM  0x20000000 0x28000
	{
		* (+RW, +ZI)
	}
}

